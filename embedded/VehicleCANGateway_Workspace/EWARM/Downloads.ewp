# IAR project Downloads.ewp, settings and files
configuration Downloads (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL33KC ST STM32WL33KC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WL3XX; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32WL3x_HAL_Driver/Inc; ../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WL3X/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Downloads.hex
  ILINK.IlinkOutputFile: Downloads.out
  ILINK.IlinkIcfFile: stm32wl3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Drivers/STM32WL3x_HAL_Driver
    ../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_adc.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal_cortex.c stm32wl3x_hal.c stm32wl3x_hal_mrsubg.c stm32wl3x_ll_utils.c stm32wl3x_hal_spi.c stm32wl3x_hal_spi_ex.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c stm32wl3x_hal_uart.c stm32wl3x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wl3x.c
